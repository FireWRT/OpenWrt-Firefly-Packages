## applications/mtk-nvram/config.in
```kconfig
menu "nvram Features"
	depends on PACKAGE_mtk-nvram
config NVRAM_MTD_NAME
	string "mtd name for nvram"
	default "Config"
endmenu
```
